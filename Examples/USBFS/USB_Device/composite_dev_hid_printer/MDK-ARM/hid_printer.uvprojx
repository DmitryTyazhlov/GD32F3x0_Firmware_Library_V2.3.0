# Keil uVision project hid_printer.uvprojx, settings and files
target composite_hid_printer (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F350RB GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hid_printer +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_FS,GD32F350
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include;..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\device\class\hid\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\device\class\printer\Include;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../src/: app.c gd32f3x0_hw.c gd32f3x0_it.c hid_printer_wrapper.c custom_hid_itf.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group GD32F3x0_StdPeriph_Driver
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_ctc.c gd32f3x0_syscfg.c
  group GD32F3x0_EVAL
    ../../../../../Utilities/: gd32f350r_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F3x0_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F3x0_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32F3x0_usbfs_library/device/class/printer/Source/: printer_core.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
